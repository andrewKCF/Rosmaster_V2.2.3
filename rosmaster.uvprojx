# Keil uVision project rosmaster.uvprojx, settings and files
target Rosmaster (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rosmaster +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\Source\BSP;.\Source\APP;.\Source\DEBUG;.\FreeRTOS\inc;.\Source\MEMS;.\Source\TOOL;.\Source\IMU;.\Source\DMP;.\Source\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Support
    ./CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ./Source/APP/: main.c protocol.c app.c app_uart_servo.c app_oled.c app_bat.c app_motion.c app_pid.c app_flash.c app_sbus.c app_mecanum.c app_rgb.c app_ackerman.c app_math.c app_fourwheel.c app_angle.c
  group BSP
    ./Source/BSP/: bsp.c bsp_beep.c bsp_flash.c bsp_timer.c bsp_usart.c bsp_wdg.c bsp_io_i2c.c bsp_motor.c bsp_key.c bsp_encoder.c bsp_pwmServo.c oled_fonts.c bsp_ssd1306.c bsp_spi.c bsp_adc.c bsp_can.c bsp_rgb.c bsp_mpu9250.c bsp_mpuiic.c
  group FWLIB
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DEBUG
    ./Source/DEBUG/: yb_debug.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group TOOL
    ./Source/TOOL/: tool_pid.c
  group eMPL
    ./Source/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
